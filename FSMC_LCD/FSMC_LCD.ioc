# file: FSMC_LCD.ioc
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Mcu.Family=STM32F4
Mcu.Name=STM32F407I(E-G)Tx
Mcu.Package=LQFP176
NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PH0-OSC_IN.Mode=HSE-External-Oscillator
PH0-OSC_IN.Signal=RCC_OSC_IN
PH1-OSC_OUT.Mode=HSE-External-Oscillator
PH1-OSC_OUT.Signal=RCC_OSC_OUT
ProjectManager.HeapSize=0x200
ProjectManager.StackSize=0x400
ProjectManager.TargetToolchain=STM32CubeIDE
RCC.48MHZClocksFreq_Value=84000000
RCC.AHBFreq_Value=168000000
RCC.APB1CLKDivider=RCC_HCLK_DIV4
RCC.APB1Freq_Value=42000000
RCC.APB1TimFreq_Value=84000000
RCC.APB2CLKDivider=RCC_HCLK_DIV2
RCC.APB2Freq_Value=84000000
RCC.APB2TimFreq_Value=168000000
RCC.CortexFreq_Value=168000000
RCC.HCLKFreq_Value=168000000
RCC.HSE_VALUE=25000000
RCC.HSI_VALUE=16000000
RCC.LSE_VALUE=32768
RCC.PLLM=8
RCC.PLLN=168
RCC.SYSCLKFreq_VALUE=168000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
RCC.VCOOutputFreq_Value=336000000
board=custom

// file: Core/Src/main.c
#include "bsp.h"
#include "images.h"
#include "main_enum.h"
#include "main_menu.h"
#include "touch_test.h"
#include "hard_test.h"
#include "http_server.h"

#define PLL_M      25      // 외부 25MHz 크리스탈 사용
#define PLL_N      336     // 25MHz * 336 = 8400MHz
#define PLL_P      2       // 8400MHz / 2 = 168MHz (SYSCLK)
#define PLL_Q      7       // USB OTG FS, SDIO, RNG 클럭용 (PLL 출력 / 7)

void SystemClock_Config(void);
static void MX_GPIO_Init(void);

int main(void)
{
  /*
   Since the startup file of the ST firmware library has already executed the CPU system clock initialization, there is no need to configure the system clock again.
   The startup file `startup_stm32f4xx.s` will call the `void SystemInit(void)` function in `system_stm32f4xx.c`.
   The `SystemInit()` function configures the CPU main clock frequency, internal Flash access speed, and optional external SRAM FSMC initialization.
   The main crystal oscillator of the Anfu STM32-V5 development board is 25MHz, and the internal PLL multiplies it to 168MHz.
   If you need to change the main frequency, you can modify the following file:
   `\User\bsp_stm32f4xx\system_stm32f4xx.c`
   Several macros at the beginning of the file are PLL multiplier parameters. By modifying these macros, you can change the main frequency without modifying the hardware.
  */
  uint16_t ucStatus;

  bsp_Init();

  //HAL_Init();
  SystemClock_Config();
  //MX_GPIO_Init();

  while (1)
  {

  }
}

void SystemClock_Config(void)
{
	RCC_OscInitTypeDef RCC_OscInitStruct = {0};
	RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};

	RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSE;
	RCC_OscInitStruct.HSEState = RCC_HSE_ON;
	RCC_OscInitStruct.PLL.PLLState = RCC_PLL_ON;
	RCC_OscInitStruct.PLL.PLLSource = RCC_PLLSOURCE_HSE;
	RCC_OscInitStruct.PLL.PLLM = PLL_M;
	RCC_OscInitStruct.PLL.PLLN = PLL_N;
	RCC_OscInitStruct.PLL.PLLP = RCC_PLLP_DIV2;
	RCC_OscInitStruct.PLL.PLLQ = PLL_Q;
	if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
	{
		Error_Handler();
	}
	RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK|RCC_CLOCKTYPE_SYSCLK
            					|RCC_CLOCKTYPE_PCLK1|RCC_CLOCKTYPE_PCLK2;
	RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_PLLCLK;
	RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;            // HCLK = SYSCLK = 168MHz
	RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV4; 			      // APB1 = HCLK/4 = 42MHz
	RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV2; 			      // APB2 = HCLK/2 = 84MHz

	// Flash 레이턴시 설정 (168MHz에서는 5 wait states 필요)
	if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_5) != HAL_OK)
	{
		Error_Handler();
	}
}

static void MX_GPIO_Init(void)
{

  /* GPIO Ports Clock Enable */
  __HAL_RCC_GPIOH_CLK_ENABLE();
  __HAL_RCC_GPIOA_CLK_ENABLE();

}

void Error_Handler(void)
{
  __disable_irq();
  while (1)
  {
  }
}
